Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: ND-W7A.IFC
Time: 2021-10-27T09:20:01
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: 827970755 Narada Innen-Gehäuse
In: Default Storey
Material: St12
SolidWorks Custom Properties - Material: St12; Gewicht: 296.23; Oberfläche: verzinkt

# IfcBuildingElementProxy: KURMA Blende BIM_6600201xx KURMA Blende LEDIL (B)
In: Default Storey
Material: PA 66
SolidWorks Custom Properties - Material: PA 66; Gewicht: 2.28

# IfcBuildingElementProxy: Linse_Version siehe Eigenschaften
In: Default Storey
Material: PMMA
SolidWorks Custom Properties - Version 1: A - 1 Linse f. Flächen b. 4,5m Höhe; Version 2: B - 1 Linse f. Wege bis 3m Höhe; Version 3: F - 2 Linsen f. Fläche bis 8m Höhe; Version 4: W - 2 Linsen f. Wege b. 4,5m Höhe

# IfcBuildingElementProxy: Montagefläche NARADA BIM
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: NARADA Haube BIM
In: Default Storey
Material: St12
SolidWorks Custom Properties - Material: St12; Gewicht: 530.58; Farbe 1: weiß RAL9016; Farbe 2: Sonderfarbe

# IfcBuildingElementProxy: NARADA Montageblech BIM_827970750 Narade Montageblech
In: Default Storey
Material: St12
SolidWorks Custom Properties - Material: St12; Gewicht: 551.06; Farbe 1: weiß RAL 9016; Farbe 2: Sonderfarbe

# IfcBuildingElementProxy: ND-Box f.seitl.Kabeleinführung BIM
In: Default Storey
Material: St12
SolidWorks Custom Properties - Material: St12; Gewicht: 460.15; Farbe 1: weiß RAL 9016; Farbe 2: Sonderfarbe

# IfcBuildingElementProxy: Narada Dichtung BIM
In: Default Storey
Material: EPDM
SolidWorks Custom Properties - Material: EPDM; Gewicht: 14.36

# IfcBuildingElementProxy: Narada Technik BIM
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: AX3 - AT.DS & BS,LFP 1,6Ah 3h 1,2W; Version 2: AX8 - AT.DS & BS,LFP 1,6Ah 8h 1,2W; Version 3: C - zentr. Vers. AC/DC Adressmodul; Version 4: E - für zentrale Versorgung AC/DC; Version 5: A - LPS260 Mischbetrieb Adr. 1-32; Version 6: G - SET10 Mischbetriebsbaustein; Version 7: G - MSÜ-3-S Mischbetriebsbaustein; Version 8: T - ELC Mischbetriebsbaustein; Version 9: X - über beigestellten Baustein

# IfcElementAssembly: ND-W7A
In: Default Storey
SolidWorks Custom Properties - Farbe 1: 1 - alle Gehäuseteile weiß RAL 9016; Farbe 2: X - Sonderfarbe zuzgl. Einmalkosten; Version 1: W2 - Wandmon.IP41, rücks. Kabeleinf.; Version 2: W2A - Wand IP 41 Zusatzgehäuse seitl. Kabel; Version 3: W7 - Wandmon. IP65, rücks. Kabeleinf.; Version 4: W7A - Wand IP65 Zusatzgehäuse seitl. Kabel
PSet_Mass_Property - Mass Measure: 2013.94; Area Measure: 693610 m2; Volume Measure: 407539 m3
